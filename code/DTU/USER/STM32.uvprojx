# Keil uVision project STM32.uvprojx, settings and files
target project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\LIB\inc;..\USER;..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\exti;..\SYSTEM\timer;..\SYSTEM\usart;..\SYSTEM\i2c;..\SYSTEM\spi;..\SYSTEM\can;..\SYSTEM\dma;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\BEEP;..\HARDWARE\LCD;..\HARDWARE\RTC;..\SYSTEM\fifo;..\HARDWARE\weichuan-lora-M100D_P;..\HARDWARE\WDG;..\HARDWARE\sensor-mag;..\SYSTEM\FLASH
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/weichuan-lora-M100D_P/: weichuan-m100d.c
    ../HARDWARE/sensor-mag/: sensor-mag.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/fifo/: fifo.c
    ../SYSTEM/FLASH/: flash.c
  group LIB
    ../LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group README
    ../ReadMe/: ReadMe.txt
